# Keil uVision project controller_firmware.uvprojx, settings and files
target controller_firmware (6220000::V6.22::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: controller_firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../App/BSP/Inc;../App/LIB/Inc;../App/DUT/common/Inc;../App/DUT/dac11001/Inc;../App/DUT/ad7616/inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c cordic.c gpdma.c i2c.c icache.c memorymap.c spi.c tim.c usart.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cordic.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group App/BSP
    ../App/BSP/Src/: bsp_ft.c bsp_io.c bsp_dut.c bsp_mux.c bsp_uart.c bsp_tim.c bsp_spi.c
  group App/LIB
    ../App/LIB/Src/: cevent.c clog.c uart_comm.c cmdparse.c dyncall.c dynpool.c
  group App/DUT/ad7616
    ../App/DUT/AD7616/src/: dut_ad7616.c
    ../App/DUT/ad7616/src/: ad7616_control.c ad7616_iocfg.c ad7616_sample.c
  group App/DUT/dac11001
    ../App/DUT/dac11001/src/: dut_dac11001.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
